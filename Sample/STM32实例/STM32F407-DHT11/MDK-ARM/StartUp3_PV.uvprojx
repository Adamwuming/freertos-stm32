# Keil uVision project StartUp3_PV.uvprojx, settings and files
target StartUp3_PV (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: StartUp3_PV
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;                            ../Middlewares/Third_Party/LwIP/system;                            ../Middlewares/Third_Party/LwIP/src/include;                            ../Middlewares/Third_Party/LwIP/src/include/ipv4;                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                            ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                            ../Middlewares/Third_Party/FreeRTOS/Source/include;                            ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                            ../Middlewares/Third_Party/LwIP/system/arch;                            ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;                            ../Middlewares/Third_Party/LwIP/src/include/lwip;                            ../Middlewares/Third_Party/LwIP/src/include/netif;                            ../Middlewares/Third_Party/LwIP/src/include/posix;                            ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                            ../Middlewares/Third_Party/LwIP/src/netif/ppp;                            ../Drivers/CMSIS/Include;                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                            ../Middlewares/myMiddewares/MQTT/Inc;                            ../Inc/myInc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_timebase_TIM.c ethernetif.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c freertos.c lwip.c
    ../Src/mySrc/: stMisc.c stDHT11.c stWork.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: stats.c mem.c sys.c udp.c raw.c tcp.c tcp_out.c lwip_timers.c netif.c dns.c tcp_in.c memp.c pbuf.c init.c def.c dhcp.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c api_msg.c netifapi.c err.c api_lib.c netbuf.c tcpip.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: msg_in.c mib_structs.c asn1_dec.c asn1_enc.c msg_out.c mib2.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: inet_chksum.c ip.c igmp.c ip_addr.c icmp.c inet.c autoip.c ip_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pap.c md5.c randm.c auth.c ppp.c ppp_oe.c magic.c chap.c vj.c chpms.c ipcp.c lcp.c fsm.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c timers.c queue.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sd.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/Mqtt
    ../Middlewares/myMiddewares/MQTT/: cJSON.c MQTTClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTLwIP.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 4.1.0
